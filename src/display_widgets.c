#include "display_internal.h"
#include <string.h>

static const uint8_t font5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00}, {0x00,0x07,0x00,0x07,0x00},
    {0x14,0x7F,0x14,0x7F,0x14}, {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00}, {0x00,0x1C,0x22,0x41,0x00},
    {0x00,0x41,0x22,0x1C,0x00}, {0x14,0x08,0x3E,0x08,0x14}, {0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08}, {0x00,0x60,0x60,0x00,0x00},
    {0x20,0x10,0x08,0x04,0x02}, {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31}, {0x18,0x14,0x12,0x7F,0x10},
    {0x27,0x45,0x45,0x45,0x39}, {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E}, {0x00,0x36,0x36,0x00,0x00},
    {0x00,0x56,0x36,0x00,0x00}, {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14},
    {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06}, {0x32,0x49,0x79,0x41,0x3E},
    {0x7E,0x11,0x11,0x11,0x7E}, {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41}, {0x7F,0x09,0x09,0x09,0x01},
    {0x3E,0x41,0x49,0x49,0x7A}, {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00},
    {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41}, {0x7F,0x40,0x40,0x40,0x40},
    {0x7F,0x02,0x0C,0x02,0x7F}, {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E}, {0x7F,0x09,0x19,0x29,0x46},
    {0x46,0x49,0x49,0x49,0x31}, {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F},
    {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F}, {0x63,0x14,0x08,0x14,0x63},
    {0x07,0x08,0x70,0x08,0x07}, {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00}, {0x04,0x02,0x01,0x02,0x04},
    {0x40,0x40,0x40,0x40,0x40}, {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78},
    {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20}, {0x38,0x44,0x44,0x48,0x7F},
    {0x38,0x54,0x54,0x54,0x18}, {0x08,0x7E,0x09,0x01,0x02}, {0x0C,0x52,0x52,0x52,0x3E},
    {0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00}, {0x20,0x40,0x44,0x3D,0x00},
    {0x7F,0x10,0x28,0x44,0x00}, {0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78},
    {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38}, {0x7C,0x14,0x14,0x14,0x08},
    {0x08,0x14,0x14,0x18,0x7C}, {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x20,0x7C}, {0x1C,0x20,0x40,0x20,0x1C},
    {0x3C,0x40,0x30,0x40,0x3C}, {0x44,0x28,0x10,0x28,0x44}, {0x0C,0x50,0x50,0x50,0x3C},
    {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00}, {0x00,0x00,0x7F,0x00,0x00},
    {0x00,0x41,0x36,0x08,0x00}, {0x08,0x08,0x2A,0x1C,0x08}, {0x08,0x1C,0x2A,0x08,0x08}
};


void display_draw_char_5x7(int16_t x, int16_t y, char c, bool color)
{
    if (c < 32 || c > 127) {
        c = '?';
    }
    const uint8_t *glyph = font5x7[(uint8_t)c - 32U];
    for (uint8_t col = 0; col < 5; ++col) {
        for (uint8_t row = 0; row < 7; ++row) {
            bool on = ((glyph[col] >> row) & 0x01U) != 0U;
            if (on) {
                display_draw_pixel(x + col, y + row, color);
            }
        }
    }
}

void display_draw_text_5x7(int16_t x, int16_t y, const char *text, bool color)
{
    while (*text) {
        display_draw_char_5x7(x, y, *text++, color);
        x += 6;
    }
}

void display_draw_text_centered_5x7(int16_t x, int16_t y, int16_t w, const char *text, bool color)
{
    int16_t len = 0;
    const char *p = text;
    while (*p++) len++;
    int16_t width = len * 6 - (len ? 1 : 0);
    display_draw_text_5x7(x + (w - width) / 2, y, text, color);
}

static void draw_seg(int16_t x, int16_t y, int16_t w, int16_t h, bool vertical, bool color)
{
    if (vertical) display_fill_round_rect(x, y, h, w, color);
    else display_fill_round_rect(x, y, w, h, color);
}

void display_draw_big_digit(int16_t x, int16_t y, uint8_t digit, uint8_t scale, bool color)
{
    static const uint8_t seg_map[10] = {
        0b1111110, 0b0110000, 0b1101101, 0b1111001, 0b0110011,
        0b1011011, 0b1011111, 0b1110000, 0b1111111, 0b1111011
    };
    uint8_t s = seg_map[digit % 10U];
    int16_t thick = scale;
    int16_t len = scale * 4;

    if (s & 0b1000000) draw_seg(x + thick, y, len, thick, false, color);
    if (s & 0b0100000) draw_seg(x + len + thick, y + thick, len, thick, true, color);
    if (s & 0b0010000) draw_seg(x + len + thick, y + len + 2 * thick, len, thick, true, color);
    if (s & 0b0001000) draw_seg(x + thick, y + 2 * len + 2 * thick, len, thick, false, color);
    if (s & 0b0000100) draw_seg(x, y + len + 2 * thick, len, thick, true, color);
    if (s & 0b0000010) draw_seg(x, y + thick, len, thick, true, color);
    if (s & 0b0000001) draw_seg(x + thick, y + len + thick, len, thick, false, color);
}

void display_draw_big_colon(int16_t x, int16_t y, uint8_t scale, bool color, bool on)
{
    if (!on) return;
    display_fill_circle(x, y + scale * 3, scale, color);
    display_fill_circle(x, y + scale * 8, scale, color);
}

void display_draw_battery_icon(int16_t x, int16_t y, uint8_t percent, bool charging, bool invert)
{
    bool c = !invert;
    display_draw_rect(x, y, 16, 8, c);
    display_fill_rect(x + 16, y + 2, 2, 4, c);
    uint8_t fill = (uint8_t)((percent * 12U) / 100U);
    display_fill_rect(x + 2, y + 2, fill, 4, c);
    if (charging) {
        display_draw_pixel(x + 7, y + 1, c);
        display_draw_pixel(x + 6, y + 3, c);
        display_draw_pixel(x + 8, y + 3, c);
        display_draw_pixel(x + 7, y + 5, c);
    }
}

void display_draw_step_icon(int16_t x, int16_t y, bool invert)
{
    bool c = !invert;
    display_fill_circle(x + 5, y + 4, 3, c);
    display_fill_circle(x + 10, y + 10, 4, c);
}

void display_draw_alarm_icon(int16_t x, int16_t y, bool invert)
{
    bool c = !invert;
    display_draw_circle(x + 8, y + 8, 5, c);
    display_draw_vline(x + 8, y + 8, 3, c);
    display_draw_hline(x + 8, y + 8, 3, c);
    display_draw_circle(x + 3, y + 2, 2, c);
    display_draw_circle(x + 13, y + 2, 2, c);
}

void display_draw_timer_icon(int16_t x, int16_t y, bool invert)
{
    bool c = !invert;
    display_draw_circle(x + 8, y + 9, 6, c);
    display_draw_rect(x + 6, y + 1, 4, 2, c);
    display_draw_vline(x + 8, y + 9, 3, c);
    display_draw_hline(x + 8, y + 9, 2, c);
}

void display_draw_gear_icon(int16_t x, int16_t y, bool invert)
{
    bool c = !invert;
    display_draw_circle(x + 8, y + 8, 5, c);
    display_fill_circle(x + 8, y + 8, 2, c);
    display_draw_vline(x + 8, y, 3, c);
    display_draw_vline(x + 8, y + 13, 3, c);
    display_draw_hline(x, y + 8, 3, c);
    display_draw_hline(x + 13, y + 8, 3, c);
}

void display_draw_info_icon(int16_t x, int16_t y, bool invert)
{
    bool c = !invert;
    display_draw_circle(x + 8, y + 8, 7, c);
    display_fill_circle(x + 8, y + 4, 1, c);
    display_draw_vline(x + 8, y + 7, 5, c);
}

void display_draw_progress_bar(int16_t x, int16_t y, int16_t w, int16_t h, uint8_t percent, bool invert)
{
    bool c = !invert;
    display_draw_round_rect(x, y, w, h, c);
    int16_t fill = (int16_t)(((w - 4) * percent) / 100U);
    if (fill > 0) {
        display_fill_round_rect(x + 2, y + 2, fill, h - 4, c);
    }
}

void display_draw_wifi_icon(int16_t x, int16_t y, bool connected, bool invert)
{
    bool c = !invert;
    // Simple WiFi signal bars
    display_draw_hline(x + 2, y + 12, 12, c);  // bottom bar
    display_draw_hline(x + 4, y + 10, 8, c);   // middle bar
    display_draw_hline(x + 6, y + 8, 4, c);    // top bar
    display_draw_vline(x + 8, y + 6, 2, c);    // center

    if (!connected) {
        display_draw_pixel(x + 3, y + 3, c);
        display_draw_pixel(x + 4, y + 4, c);
        display_draw_pixel(x + 5, y + 5, c);
        display_draw_pixel(x + 6, y + 6, c);
        display_draw_pixel(x + 7, y + 7, c);
        display_draw_pixel(x + 8, y + 8, c);
        display_draw_pixel(x + 9, y + 9, c);
        display_draw_pixel(x + 10, y + 10, c);
        display_draw_pixel(x + 11, y + 11, c);
    }
}
